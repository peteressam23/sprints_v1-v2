# Keil uVision project v3_task_BrightControl.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: gpt_interface.h common.h gpio_interface.h gpio_private.h gpio_program.c gpt_private.h gpt_program.c app.h app.c led.c led_config.c led_config.h led_interface.h button.c button_config.c button_config.h button_interface.h timer_manager_interface.h timer_manager_program.c main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
